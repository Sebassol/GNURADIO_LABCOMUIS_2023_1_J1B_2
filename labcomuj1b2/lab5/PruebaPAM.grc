options:
  parameters:
    author: Manuel_Solano_Y_Fabian_Jimenez
    generate_options: qt_gui
    id: PruebaPAM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud de mensaje
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: ancho de pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de Pulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: ModulacionPAM_0
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModulacionPAM_0, '0', qtgui_freq_sink_x_0, '0']
- [ModulacionPAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModulacionPAM_0, '1', qtgui_freq_sink_x_0, '1']
- [ModulacionPAM_0, '1', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0, '0', ModulacionPAM_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
